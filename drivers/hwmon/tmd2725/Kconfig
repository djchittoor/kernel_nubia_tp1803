## drivers/hwmon/tmd2725/Kconfig
```kconfig
config SENSORS_TMD2725
	tristate "TMD2725 Ambient Light sensor"
	default n
	help
	  Enables support for TMD2725 Ambient Light sensor
```
